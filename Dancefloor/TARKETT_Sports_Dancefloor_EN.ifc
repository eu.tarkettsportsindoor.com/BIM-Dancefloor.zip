Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Numéro du projet
Time: 2021-12-21T23:12:46
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190510_1515(x64) - Exporter 18.4.0.0 - Interface alternative d'export 18.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Dec 21 23:12:46 2021 * Host: SWIFT * Database: C:\Users\MFBIM~1\AppData\Local\Temp\{9DDAB33D-89BB-494B-A357-A7792BFBF237}\ifc * Database version: 5507 * Database creation date: Tue Dec 21 23:12:45 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Dec 21 23:12:45 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Dec 21 23:12:45 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Numéro du projet
LongName: Nom du projet; Phase: Etat du projet

# IfcSite, Default
RefLatitude: 42, 12, 46, 804504; RefLongitude: -71, -2, 0, -602416; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey: Niveau:Pointe 8 mm, Niveau 1
LongName: Niveau 1; Elevation: 0 mm

# IfcBuildingElementProxy: Logo, TARKETT Sports - Logo:Logo:205675
In: Niveau 1
Type - Material: TARKETT - Logo - Bleu
Type - Pset_BuildingElementProxyCommon - Reference: Logo
Type - Pset_QuantityTakeOff - Reference: Logo
Pset_BuildingElementProxyCommon - sets with these values: 2

# IfcBuildingElementProxy: Texte 3D:600mm Arial, Texte 3D:600mm Arial:205666
In: Niveau 1
Pset_BuildingElementProxyCommon - Reference: 600mm Arial; sets with these values: 2

# IfcBuildingElementProxy: Texte 3D:80mm Arial (2)
In: Niveau 1
Pset_BuildingElementProxyCommon - Reference: 80mm Arial; sets with these values: 2
Name (Texte 3D:80mm Arial:...)
445543
472571

# IfcCovering: Sol:TARKETT - Dancefloor - Black, Sol:TARKETT - Dancefloor - Black:372794
In: Niveau 1
Type - PredefinedType: FLOORING; Material: TARKETT - Omnisports Speed - Uni BLACK 3.45 mm
Type - Pset_ConcreteElementGeneral - FireRating: Cfl - s1
Type - Pset_CoveringCommon - Reference: TARKETT - Dancefloor - Black; FireRating: Cfl - s1
Type - Pset_ManufacturerTypeInformation - Manufacturer: TARKETT
Type - Pset_QuantityTakeOff - Reference: TARKETT - Dancefloor - Black
Type - PSet_Tarkett_EN - Thermal resistance: 0.05 kg/K/s3; Underfloor heating: yes; Tensile strength: 0; Type of floorcovering: Heterogeneous indoor floorcoverings; Flammability: Cfl - s1; Design: Black; Dimension: 2m x 15lm; Plasticizer: Phthalate-free; Reaction to fire: Cfl - s1; Reduction of in-room impact noise: Class A (≤65dB); Residual indentation: ≤ 0.50 mm; Total mass: 3.04; Total thickness: 3.45 mm; Total VOC emissions (after 28 days): -; URL: https://www.tarkettsportsindoor.com/; Acoustic performance: 20 dB; Board dimensions: -; Elongation at break: -; Friction: ≥ 90; Resistance to a rolling load: -; Resistance to wear: ≤ 1g; Shock absorption: ≥ 4%; Specular gloss: ≤ 30; Temperature range: -; Vertical ball behaviour: -; Vertical deformation: ≤ 0.8 mm
Classification: C3020400 Flooring (Uniformat)
Pset_CoveringCommon - TotalThickness: 3.45 mm

# IfcCovering: Sol:TARKETT - Dancefloor - Medium Grey, Sol:TARKETT - Dancefloor - Medium Grey:372803
In: Niveau 1
Type - PredefinedType: FLOORING; Material: TARKETT - Omnisports Speed - Uni MEDIUM GREY 3.45 mm
Type - Pset_ConcreteElementGeneral - FireRating: Cfl - s1
Type - Pset_CoveringCommon - Reference: TARKETT - Dancefloor - Medium Grey; FireRating: Cfl - s1
Type - Pset_ManufacturerTypeInformation - Manufacturer: TARKETT
Type - Pset_QuantityTakeOff - Reference: TARKETT - Dancefloor - Medium Grey
Type - PSet_Tarkett_EN - Thermal resistance: 0.05 kg/K/s3; Underfloor heating: yes; Tensile strength: 0; Type of floorcovering: Heterogeneous indoor floorcoverings; Flammability: Cfl - s1; Design: Medium Grey; Dimension: 2m x 15lm; Plasticizer: Phthalate-free; Reaction to fire: Cfl - s1; Reduction of in-room impact noise: Class A (≤65dB); Residual indentation: ≤ 0.50 mm; Total mass: 3.04; Total thickness: 3.45 mm; Total VOC emissions (after 28 days): -; URL: https://www.tarkettsportsindoor.com/; Acoustic performance: 20 dB; Board dimensions: -; Elongation at break: -; Friction: ≥ 90; Resistance to a rolling load: -; Resistance to wear: ≤ 1g; Shock absorption: ≥ 4%; Specular gloss: ≤ 30; Temperature range: -; Vertical ball behaviour: -; Vertical deformation: ≤ 0.8 mm
Classification: C3020400 Flooring (Uniformat)
Pset_CoveringCommon - TotalThickness: 3.45 mm
