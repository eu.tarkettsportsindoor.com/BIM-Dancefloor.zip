Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Numéro du projet
Time: 2021-12-21T23:18:14
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190510_1515(x64) - Exporter 18.4.0.0 - Interface alternative d'export 18.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Dec 21 23:18:14 2021 * Host: SWIFT * Database: C:\Users\MFBIM~1\AppData\Local\Temp\{061A8234-5670-4E46-9468-7B2F8ED74B3D}\ifc * Database version: 5507 * Database creation date: Tue Dec 21 23:18:13 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Dec 21 23:18:14 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Dec 21 23:18:14 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Numéro du projet
LongName: Nom du projet; Phase: Etat du projet

# IfcSite, Default
RefLatitude: 42, 12, 46, 804504; RefLongitude: -71, -2, 0, -602416; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey: Niveau:Pointe 8 mm, Niveau 1
LongName: Niveau 1; Elevation: 0 mm

# IfcBuildingElementProxy: Logo, TARKETT Sports - Logo:Logo:205675
In: Niveau 1
Type - Material: TARKETT - Logo - Bleu
Type - Pset_BuildingElementProxyCommon - Reference: Logo
Type - Pset_QuantityTakeOff - Reference: Logo
Pset_BuildingElementProxyCommon - sets with these values: 2

# IfcBuildingElementProxy: Texte 3D:600mm Arial, Texte 3D:600mm Arial:205666
In: Niveau 1
Pset_BuildingElementProxyCommon - Reference: 600mm Arial; sets with these values: 2

# IfcBuildingElementProxy: Texte 3D:80mm Arial (2)
In: Niveau 1
Pset_BuildingElementProxyCommon - Reference: 80mm Arial; sets with these values: 2
Name (Texte 3D:80mm Arial:...)
445543
472571

# IfcCovering: Sol:TARKETT - Dancefloor - Black, Sol:TARKETT - Dancefloor - Black:372794
In: Niveau 1
Type - PredefinedType: FLOORING; Material: TARKETT - Omnisports Speed - Uni BLACK 3.45 mm
Type - Pset_ConcreteElementGeneral - FireRating: Cfl - s1
Type - Pset_CoveringCommon - Reference: TARKETT - Dancefloor - Black; FireRating: Cfl - s1
Type - Pset_ManufacturerTypeInformation - Manufacturer: TARKETT
Type - Pset_QuantityTakeOff - Reference: TARKETT - Dancefloor - Black
Type - PSet_Tarkett_ES - Resistencia térmica: 0.05 kg/K/s3; Calefacción radiante: yes; Resistencia a la tracción: 0; Tipo de pavimento: Pavimento de interior en vinilo heterogéneo; Inflamabilidad: Cfl - s1; Design: Black; Formato: 2m x 15lm; Plastificante: Libre de ftalatos; Reacción al fuego: Cfl - s1; Absorción acústica: Clase A (≤65dB); Punzonamiento estático: ≤ 0.50 mm; Peso total: 3.04; Espesor total: 3.45 mm; Emisiones COV tras 28 días: -; URL: https://www.tarkettsportsindoor.com/; Abrasion: ≤ 1g; Absorción de impacto: ≥ 4%; Alargamiento a la rotura: -; Brillo especular: ≤ 30; Coeficiente de fricción: ≥ 90; Deformación vertical: ≤ 0.8 mm; Dimensiones de las tablas: -; Rango de temperatura: -; Rebote del Balón: -; Rendimiento acústico: 20 dB; Resistencia a cargas rodantes: -
Classification: C3020400 Flooring (Uniformat)
Pset_CoveringCommon - TotalThickness: 3.45 mm

# IfcCovering: Sol:TARKETT - Dancefloor - Medium Grey, Sol:TARKETT - Dancefloor - Medium Grey:372803
In: Niveau 1
Type - PredefinedType: FLOORING; Material: TARKETT - Omnisports Speed - Uni MEDIUM GREY 3.45 mm
Type - Pset_ConcreteElementGeneral - FireRating: Cfl - s1
Type - Pset_CoveringCommon - Reference: TARKETT - Dancefloor - Medium Grey; FireRating: Cfl - s1
Type - Pset_ManufacturerTypeInformation - Manufacturer: TARKETT
Type - Pset_QuantityTakeOff - Reference: TARKETT - Dancefloor - Medium Grey
Type - PSet_Tarkett_ES - Resistencia térmica: 0.05 kg/K/s3; Calefacción radiante: yes; Resistencia a la tracción: 0; Tipo de pavimento: Pavimento de interior en vinilo heterogéneo; Inflamabilidad: Cfl - s1; Design: Medium Grey; Formato: 2m x 15lm; Plastificante: Libre de ftalatos; Reacción al fuego: Cfl - s1; Absorción acústica: Clase A (≤65dB); Punzonamiento estático: ≤ 0.50 mm; Peso total: 3.04; Espesor total: 3.45 mm; Emisiones COV tras 28 días: -; URL: https://www.tarkettsportsindoor.com/; Abrasion: ≤ 1g; Absorción de impacto: ≥ 4%; Alargamiento a la rotura: -; Brillo especular: ≤ 30; Coeficiente de fricción: ≥ 90; Deformación vertical: ≤ 0.8 mm; Dimensiones de las tablas: -; Rango de temperatura: -; Rebote del Balón: -; Rendimiento acústico: 20 dB; Resistencia a cargas rodantes: -
Classification: C3020400 Flooring (Uniformat)
Pset_CoveringCommon - TotalThickness: 3.45 mm
