Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Numéro du projet
Time: 2021-12-21T23:23:18
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190510_1515(x64) - Exporter 18.4.0.0 - Interface alternative d'export 18.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Dec 21 23:23:18 2021 * Host: SWIFT * Database: C:\Users\MFBIM~1\AppData\Local\Temp\{54A0AD5D-8FFA-401B-B5E7-B6F4CE37FB56}\ifc * Database version: 5507 * Database creation date: Tue Dec 21 23:23:16 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Dec 21 23:23:17 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Dec 21 23:23:17 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Numéro du projet
LongName: Nom du projet; Phase: Etat du projet

# IfcSite, Default
RefLatitude: 42, 12, 46, 804504; RefLongitude: -71, -2, 0, -602416; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey: Niveau:Pointe 8 mm, Niveau 1
LongName: Niveau 1; Elevation: 0 mm

# IfcBuildingElementProxy: Logo, TARKETT Sports - Logo:Logo:205675
In: Niveau 1
Type - Material: TARKETT - Logo - Bleu
Type - Pset_BuildingElementProxyCommon - Reference: Logo
Type - Pset_QuantityTakeOff - Reference: Logo
Pset_BuildingElementProxyCommon - sets with these values: 2

# IfcBuildingElementProxy: Texte 3D:600mm Arial, Texte 3D:600mm Arial:205666
In: Niveau 1
Pset_BuildingElementProxyCommon - Reference: 600mm Arial; sets with these values: 2

# IfcBuildingElementProxy: Texte 3D:80mm Arial (2)
In: Niveau 1
Pset_BuildingElementProxyCommon - Reference: 80mm Arial; sets with these values: 2
Name (Texte 3D:80mm Arial:...)
445543
472571

# IfcCovering: Sol:TARKETT - Dancefloor - Black, Sol:TARKETT - Dancefloor - Black:372794
In: Niveau 1
Type - PredefinedType: FLOORING; Material: TARKETT - Omnisports Speed - Uni BLACK 3.45 mm
Type - Pset_ConcreteElementGeneral - FireRating: Cfl - s1
Type - Pset_CoveringCommon - Reference: TARKETT - Dancefloor - Black; FireRating: Cfl - s1
Type - Pset_ManufacturerTypeInformation - Manufacturer: TARKETT
Type - Pset_QuantityTakeOff - Reference: TARKETT - Dancefloor - Black
Type - PSet_Tarkett_FR - Résistance thermique: 0.05 kg/K/s3; Compatible avec chauffage au sol: yes; Résistance à la traction: 0; Type de revêtement de sol: PVC hétérogène; Tenue au feu: Cfl - s1; Design: Black; Format: 2m x 15lm; Plastifiant: Sans phtalate; Réaction au feu: Cfl - s1; Sonorité à la marche: Classe A (≤65dB); Poinçonnement rémanent: ≤ 0.50 mm; Masse surfacique totale: 3.04; Épaisseur totale: 3.45 mm; Emissions COVT après 28 jours: -; URL: https://www.tarkettsportsindoor.com/; Abrasion: ≤ 1g; Absorption des chocs: ≥ 4%; Allongement à la rupture: -; Brillance: ≤ 30; Coefficient de friction: ≥ 90; Déformation verticale: ≤ 0.8 mm; Dimensions des planches: -; Écart de température: -; Performance acoustique: 20 dB; Rebond vertical du ballon: -; Résistance aux charges roulantes: -
Classification: C3020400 Flooring (Uniformat)
Pset_CoveringCommon - TotalThickness: 3.45 mm

# IfcCovering: Sol:TARKETT - Dancefloor - Medium Grey, Sol:TARKETT - Dancefloor - Medium Grey:372803
In: Niveau 1
Type - PredefinedType: FLOORING; Material: TARKETT - Omnisports Speed - Uni MEDIUM GREY 3.45 mm
Type - Pset_ConcreteElementGeneral - FireRating: Cfl - s1
Type - Pset_CoveringCommon - Reference: TARKETT - Dancefloor - Medium Grey; FireRating: Cfl - s1
Type - Pset_ManufacturerTypeInformation - Manufacturer: TARKETT
Type - Pset_QuantityTakeOff - Reference: TARKETT - Dancefloor - Medium Grey
Type - PSet_Tarkett_FR - Résistance thermique: 0.05 kg/K/s3; Compatible avec chauffage au sol: yes; Résistance à la traction: 0; Type de revêtement de sol: PVC hétérogène; Tenue au feu: Cfl - s1; Design: Medium Grey; Format: 2m x 15lm; Plastifiant: Sans phtalate; Réaction au feu: Cfl - s1; Sonorité à la marche: Classe A (≤65dB); Poinçonnement rémanent: ≤ 0.50 mm; Masse surfacique totale: 3.04; Épaisseur totale: 3.45 mm; Emissions COVT après 28 jours: -; URL: https://www.tarkettsportsindoor.com/; Abrasion: ≤ 1g; Absorption des chocs: ≥ 4%; Allongement à la rupture: -; Brillance: ≤ 30; Coefficient de friction: ≥ 90; Déformation verticale: ≤ 0.8 mm; Dimensions des planches: -; Écart de température: -; Performance acoustique: 20 dB; Rebond vertical du ballon: -; Résistance aux charges roulantes: -
Classification: C3020400 Flooring (Uniformat)
Pset_CoveringCommon - TotalThickness: 3.45 mm
